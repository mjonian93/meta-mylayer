FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-bbappend-patch.patch"
SRC_URI += "file://lwl-fragment.cfg"
